mp1 out a pu_n1 vdd pch l='length' W='param4 * log_efwp'qweqwccccccccccccccc
mp2 pu_n1 b pu_n3 vdd pch l='length' W='param2 * log_efwp'qbbbbbbdcfbbnvnvbnvbnvbnvbnvbnbnfgghfghfghfghfghfghfg
mp3 p3_n3 d pu_n4 vdd pch l='length' W='param4 * log_efwp'aaaaaaaaa
mp4 pu_n4 c vdd vdd pch l='length' W='param4 * log_efwp'qweqweqweqwe
MN5 out a GND GND nch L='length' W='1 * log_efWn'
MN6 out b GND GND nch L='length' W='1 * log_efWn'
MN7 out d GND GND nch L='length' W='1 * log_efWn'
MN8 out c GND GND nch L='length' W='1 * log_efWn'
